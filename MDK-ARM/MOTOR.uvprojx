# Keil uVision project MOTOR.uvprojx, settings and files
target MOTOR (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G431RBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: MOTOR +hex
  c flags: OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: STM32G431xx,__FPU_PRESENT=1U,__TARGET_FPU_VFP,ARM_MATH_CM4,__CC_ARM,USE_HAL_DRIVER
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../User/MotorControl;../User/GlobalControl;../User/LedControl;../User/LcdControl;../User/UsartControl;../User/KeyControl
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group LedControl
    ../User/LedControl/: led_task.c
  group LcdControl
    ../User/LcdControl/: lcd_drv.c lcd_mid.c lcd_task.c
  group KeyControl
    ../User/KeyControl/: key_drv.c key_task.c
  group UsartControl
    ../User/UsartControl/: usart_task.c
  group MotorControl
    ../User/MotorControl/: motor_system.c motor_identify.c motor_sensoruse.c motor_sensorless.c motor_publicdata.c position_drv.c observer_drv.c encoder_drv.c sample_drv.c speed_drv.c math_drv.c foc_drv.c pid_drv.c
  group Global
    ../User/GlobalControl/: global_control.c
  group ReadMe
    ../User/ReadMe/: read_me.txt
software components: CMSIS:CORE 4.3.0
